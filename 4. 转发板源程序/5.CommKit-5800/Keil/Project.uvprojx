# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: TAE32G5800 Tai-Action
  pack: Tai-Action.TAE32G58xx_DFP.1.2.3
  cpu: IRAM(0x20000000,0x10000) IRAM2(0x20010000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CommKit-5800 +hex
  AfterMake: AfterBuildHandler.bat $J #L
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\devices;..\Drivers\TAE32G58xx_Device;..\Drivers\TAE32G58xx_Driver;..\libs;..\main;..\modbus;..\pmbus;..\Utilities;..\Utilities\dbg
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: .\tae32g58xx_ac6_flash.sct
  link misc: --diag_suppress=L6314W
  group main
    ../main/: iap_transfer.c iap_transfer.h main.c main.h sys_mgr.c sys_mgr.h tae_dbg_conf.h tae32g58xx_it.c tae32g58xx_ll_conf.h tae32g58xx_ll_msp.c vars.c vars.h
  group pmbus
    ../pmbus/: pmbusm.c pmbusm.h pmbus_iap.c pmbus_iap.h
  group modbus
    ../modbus/: modbus.h modbus_var.c modbus_var.h modbuss.c modbuss.h canm_modbus.c canm_modbus.h modbus_iap.c modbus_iap.h modbusm.c modbusm.h
  group devices
    ../devices/: dac.c dac.h delay.c delay.h gpio.c gpio.h iwdg.c iwdg.h led.c led.h soft_i2c.c soft_i2c.h timer.c timer.h uart.c uart.h canm.c canm.h
  group libs
    ../libs/: crc8.c crc8.h crc16.c crc16.h ring_buff.c ring_buff.h
  group Drivers/TAE32G58xx_Driver
    ../Drivers/TAE32G58xx_Driver/: tae32g58xx_ll.c tae32g58xx_ll.h tae32g58xx_ll_adc.c tae32g58xx_ll_adc.h tae32g58xx_ll_can.c tae32g58xx_ll_can.h tae32g58xx_ll_cmp.c tae32g58xx_ll_cmp.h tae32g58xx_ll_cordic.c tae32g58xx_ll_cordic.h tae32g58xx_ll_cortex.c tae32g58xx_ll_cortex.h tae32g58xx_ll_dac.c tae32g58xx_ll_dac.h tae32g58xx_ll_def.h tae32g58xx_ll_dma.c tae32g58xx_ll_dma.h tae32g58xx_ll_eflash.c tae32g58xx_ll_eflash.h tae32g58xx_ll_gpio.c tae32g58xx_ll_gpio.h tae32g58xx_ll_hrpwm.c tae32g58xx_ll_hrpwm.h tae32g58xx_ll_i2c.c tae32g58xx_ll_i2c.h tae32g58xx_ll_iir.c tae32g58xx_ll_iir.h tae32g58xx_ll_iwdg.c tae32g58xx_ll_iwdg.h tae32g58xx_ll_pdm.c tae32g58xx_ll_pdm.h tae32g58xx_ll_qei.c tae32g58xx_ll_qei.h tae32g58xx_ll_rcu.c tae32g58xx_ll_rcu.h tae32g58xx_ll_spi.c tae32g58xx_ll_spi.h tae32g58xx_ll_sysctrl.c tae32g58xx_ll_sysctrl.h tae32g58xx_ll_tmr.c tae32g58xx_ll_tmr.h tae32g58xx_ll_uart.c tae32g58xx_ll_uart.h tae32g58xx_ll_usb.c tae32g58xx_ll_usb.h tae32g58xx_ll_usb_com.h tae32g58xx_ll_wwdg.c tae32g58xx_ll_wwdg.h tae32g58xx_ll_xif.c tae32g58xx_ll_xif.h
  group Drivers/TAE32G58xx_Device
    ../Drivers/TAE32G58xx_Device/: myChip.h myChip_struct.h startup_tae32g58xx.c system_myChip.h system_tae32g58xx.c tae32g58xx.h
  group Utilities/dbg
    ../Utilities/dbg/: tae_dbg.h tae_dbg_conf_template.h user_debug.c user_debug.h
software components: CMSIS:CORE 5.4.0
