# Keil uVision project ProjectTemplate.uvprojx, settings and files
target FLASH (6140001::V6.14.1::ARMCLANG)
  device: TAE32G5800 Tai-Action
  pack: Tai-Action.TAE32G58xx_DFP.1.3.1
  cpu: IRAM(0x20000000,0x10000) IRAM2(0x20010000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 259B_LLC_V_1_2_0_20260820_iap_release +hex
  AfterMake: .\FLASH\AfterBuildHandler.bat $J #L
  c flags: Optim=5 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c include: ..\..\..\Drivers\TAE32G58xx_Device\Inc;..\..\..\Drivers\TAE32G58xx_Driver\Inc;..\..\..\Utilities;..\..\User\Inc;..\..\..\APP\include;..\..\..\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: .\FLASH\tae32g58xx_ac6_flash.sct
  group ProjectTemplate/User
    ../../User/Src/: main.c tae32g58xx_it.c tae32g58xx_ll_msp.c
  group dualbank_common
    ../../../common/src/: iap_config.c iap_runtime.c tae32_iap_port.c dualbank_boot.c
  group APP
    ../../../APP/source/: adc_app.c hrpwm_app.c dac_app.c gpio_app.c vofa_app.c can_app.c uart_app.c pri_sec_commun.c protection_app.c communication_app.c func_app.c init_app.c variables_init_app.c pid_app.c pr_control_app.c save_data.c llc_app.c tmr_app.c variables_define_app.c
    ../../../APP/include/: variables_define_app.h
  group Documentation
    ../../: readme.md
  group Drivers/TAE_Driver
    ../../../Drivers/TAE32G58xx_Driver/Src/: tae32g58xx_ll.c tae32g58xx_ll_cortex.c tae32g58xx_ll_rcu.c tae32g58xx_ll_gpio.c tae32g58xx_ll_uart.c tae32g58xx_ll_sysctrl.c tae32g58xx_ll_dma.c tae32g58xx_ll_eflash.c tae32g58xx_ll_tmr.c tae32g58xx_ll_iir.c tae32g58xx_ll_cordic.c tae32g58xx_ll_qei.c tae32g58xx_ll_iwdg.c tae32g58xx_ll_wwdg.c tae32g58xx_ll_i2c.c tae32g58xx_ll_spi.c tae32g58xx_ll_can.c tae32g58xx_ll_usb.c tae32g58xx_ll_xif.c tae32g58xx_ll_adc.c tae32g58xx_ll_dac.c tae32g58xx_ll_cmp.c tae32g58xx_ll_pdm.c tae32g58xx_ll_hrpwm.c
  group Drivers/TAE_Device
    ../../../Drivers/TAE32G58xx_Device/Src/: startup_tae32g58xx.c system_tae32g58xx.c
  group Utilities/Debug
    ../../../Utilities/dbg/: user_debug.c
target SRAM (6140000::V6.14::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: ProjectTemplate +hex
  AfterMake: fromelf --bin !L --output $L@L.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c include: ..\..\..\Drivers\TAE32G58xx_Device\Inc;..\..\..\Drivers\TAE32G58xx_Driver\Inc;..\..\..\Utilities;..\..\User\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\SRAM\tae32g58xx_ac6_sram.sct
  group left out of the first target's files
    ../../../common/src/: dualbank_boot.c iap_config.c iap_runtime.c tae32_iap_port.c
software components: CMSIS:CORE 5.4.0
